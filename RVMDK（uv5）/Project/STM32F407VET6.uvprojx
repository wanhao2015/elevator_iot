# Keil uVision project STM32F407VET6.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VET6 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\System\delay;..\System\sys;..\System\usart;..\Hardware\LED;..\Hardware\KEY;..\Hardware\TIMER;..\Hardware\EXTI;..\Hardware\STATE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../Hardware/LED/: led.c
    ../Hardware/KEY/: key.c
    ../Hardware/TIMER/: timer.c
    ../Hardware/EXTI/: exti.c
    ../Hardware/STATE/: state.c
  group SYSTEM
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
  group STARTUP
    ../Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c
  group DOC
    ../Doc/: Readme.txt
